Commit message: Added competition script support for notifysetpointstop api

File: safe_control_gym/envs/gym_pybullet_drones/assets/cf2x.urdf (robot description, URDF)
Before this commit: robot cf2, 6 links, 5 joints
Links:
- link base_link: mass 0.027 -> 0.03454
